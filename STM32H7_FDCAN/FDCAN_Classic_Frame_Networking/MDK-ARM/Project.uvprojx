# Keil uVision project Project.uvprojx, settings and files
target STM32H743I_EVAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743I_EVAL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_STM32H743I_EVAL,USE_IOEXPANDER
  c include: ..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Src;..\Drivers\BSP\STM32H743I_EVAL;..\Src;..\Inc;..\Drivers\BSP\Components\mfxstm32l152;..\User\KEY;..\User\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Drivers/BSP/STM32H743I_EVAL
    ../Drivers/BSP/STM32H743I_EVAL/: stm32h743i_eval.c stm32h743i_eval_io.c
  group Example/MDK-ARM
    ./: startup_stm32h743xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Example/User
    ../Src/: stm32h7xx_it.c main.c stm32h7xx_hal_msp.c
  group Doc
    ../: readme.txt
  group STM32H7_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_dma.c stm32h7xx_hal_i2c.c stm32h7xx_hal_rcc.c stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_cortex.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_uart.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart_ex.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group User
    ../User/LED/: led.c
software components: CMSIS:CORE 5.0.1
